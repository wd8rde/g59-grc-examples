<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>(coarse_freq + fine_freq)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>freq_cal</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>/home/rab/projects/grc/ssb1.config</value></param>
<param><key>section</key><value>rx</value></param>
<param><key>option</key><value>freq_cal</value></param>
<param><key>writeback</key><value>freq_correction</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>attack_rate</key><value>1e-1</value></param>
<param><key>decay_rate</key><value>50e-6</value></param>
<param><key>reference</key><value>0.9</value></param>
<param><key>gain</key><value>.01</value></param>
<param><key>max_gain</key><value>gain</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>0.7</value></param>
</block>
<block>
<key>analog_am_demod_cf</key>
<param><key>id</key><value>analog_am_demod_cf_0</value></param>
<param><key>chan_rate</key><value>samp_rate</value></param>
<param><key>audio_decim</key><value>1</value></param>
<param><key>audio_pass</key><value>5000</value></param>
<param><key>audio_stop</key><value>5500</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>num_outputs</key><value>2</value></param>
<param><key>input_index</key><value>0</value></param>
<param><key>output_index</key><value>demod_mode</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>freq_correction</value></param>
<param><key>label</key><value>Freq Cal</value></param>
<param><key>value</key><value>freq_cal</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>notebook</key><value>nb_0,1</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>width</value></param>
<param><key>label</key><value>Width</value></param>
<param><key>value</key><value>2400</value></param>
<param><key>choices</key><value>[100,500,1300,2100,2400,2700,3200,6400]</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>type</key><value>drop_down</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>0,11,1,1</value></param>
<param><key>notebook</key><value>nb_0,0</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>input_index</key><value>demod_mode</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>device_name</key><value>pulse</value></param>
<param><key>num_outputs</key><value>2</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>fine_freq</value></param>
<param><key>label</key><value>Fine Frequency</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-3200</value></param>
<param><key>max</key><value>3200</value></param>
<param><key>num_steps</key><value>640</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,0,1,6</value></param>
<param><key>notebook</key><value>nb_0,0</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>nb1</value></param>
<param><key>style</key><value>wx.NB_RIGHT</value></param>
<param><key>labels</key><value>["spectrum","scope"]</value></param>
<param><key>grid_pos</key><value>0,0,16,50</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>nb_0</value></param>
<param><key>style</key><value>wx.NB_RIGHT</value></param>
<param><key>labels</key><value>['Main', 'Settings']</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>1</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>10</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_VERTICAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,30,5,1</value></param>
<param><key>notebook</key><value>nb_0,0</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>grid_pos</key><value>1,1,4,52</value></param>
<param><key>notebook</key><value>nb1,0</value></param>
<param><key>freqvar</key><value>coarse_freq</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>fft_rate</key><value>30</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>grid_pos</key><value>5,0,8,49</value></param>
<param><key>notebook</key><value>nb1,0</value></param>
<param><key>freqvar</key><value>coarse_freq</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>af_preamp</value></param>
<param><key>label</key><value>AF Preamp</value></param>
<param><key>value</key><value>False</value></param>
<param><key>true</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>4,3,1,1</value></param>
<param><key>notebook</key><value>nb_0,0</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>rf_preamp</value></param>
<param><key>label</key><value>RF Preamp</value></param>
<param><key>value</key><value>False</value></param>
<param><key>true</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>4,4,1,1</value></param>
<param><key>notebook</key><value>nb_0,0</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>attenuation</value></param>
<param><key>label</key><value>Attenuator</value></param>
<param><key>value</key><value>False</value></param>
<param><key>true</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>5,3,1,1</value></param>
<param><key>notebook</key><value>nb_0,0</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>lo_frequency</value></param>
<param><key>label</key><value>Center Frequency</value></param>
<param><key>value</key><value>10.01</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>notebook</key><value>nb_0,0</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>band_number</value></param>
<param><key>label</key><value>Band</value></param>
<param><key>value</key><value>0</value></param>
<param><key>choices</key><value>[0,1,2,3,4,5,6,7]</value></param>
<param><key>labels</key><value>['Gen','160m','80','60-40m','30-20m','17-15m','12-10m','6m']</value></param>
<param><key>type</key><value>radio_buttons</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>3,0,1,10</value></param>
<param><key>notebook</key><value>nb_0,0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>coarse_freq</value></param>
<param><key>label</key><value>Frequency Offset</value></param>
<param><key>value</key><value>-10000</value></param>
<param><key>min</key><value>-1 * (samp_rate /2)</value></param>
<param><key>max</key><value>samp_rate /2</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>2,0,1,25</value></param>
<param><key>notebook</key><value>nb_0,0</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>firdes.low_pass(1, samp_rate, width, 10, firdes.WIN_HAMMING, 6.76)</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>demod_mode</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>0</value></param>
<param><key>choices</key><value>[0,1]</value></param>
<param><key>labels</key><value>['SSB', 'AM']</value></param>
<param><key>type</key><value>radio_buttons</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>4,0,2,2</value></param>
<param><key>notebook</key><value>nb_0,0</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>tx_button</value></param>
<param><key>label</key><value>PTT</value></param>
<param><key>value</key><value>False</value></param>
<param><key>true</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>4,6,1,1</value></param>
<param><key>notebook</key><value>nb_0,0</value></param>
</block>
<block>
<key>genesis_g59</key>
<param><key>id</key><value>genesis_g59_0</value></param>
<param><key>lo_freq</key><value>lo_frequency + freq_cal</value></param>
<param><key>band_filter</key><value>band_number</value></param>
<param><key>attenuation</key><value>attenuation</value></param>
<param><key>audio_preamp</key><value>af_preamp</value></param>
<param><key>rf_preamp</key><value>rf_preamp</value></param>
<param><key>tx</key><value>tx_button</value></param>
<param><key>transverter</key><value>False</value></param>
</block>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_am_demod_cf_0</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>analog_am_demod_cf_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_1</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
